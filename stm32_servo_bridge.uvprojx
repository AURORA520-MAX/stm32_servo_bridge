# Keil uVision project stm32_servo_bridge.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_servo_bridge +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\USER;.\CORE;.\STM32F10x_FWLib\inc;.\SYSTEM\delay;.\SYSTEM\uart;.\servo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./USER/: main.c stm32f10x_it.c
  group Startup
    ./CORE/: startup_stm32f10x_md.s
  group CMSIS
    ./USER/: system_stm32f10x.c
    ./CORE/: core_cm3.c
  group StdPeriph_Driver
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/uart/: uart.c
  group Servo
    ./servo/: servo.c
